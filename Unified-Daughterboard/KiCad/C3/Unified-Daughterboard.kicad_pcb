# Repository Jugizafupe/Rynok40

File README.md:

# Rynok40
### From Russia with love💗
40% keyboard with blockers and daughterboard. Top mount. Barebone or 3d print case versions.
~~"А у той тёти помидоры дешевле"~~

## KiCad design Unified-Daughterboard/KiCad/C3/Unified-Daughterboard.kicad_pcb

Parts:
D1: SMF9.0CA; D_SOD-123_Bidirectional; Manufacturer Part No SMF9.0CA; LCSC Part No C123799
F1: ASMD1206-150; Fuse_1206_3216Metric; Manufacturer Part No ASMD1206-150; LCSC Part No C135342
G1: Unified-Daughterboard-Logo; Unified-Daughterboard-Logo.pretty
G2: Unified-Daughterboard-Name; Unified-Daughterboard-Name.pretty
J1: TYPE-C-31-M12_13; TYPE-C-31-M-12; Manufacturer Part No TYPE-C-31-M-12; LCSC Part No C165948
J2: SM04B-SRSS-TB(LF)(SN); JST-SR-4; Manufacturer Part No SM04B-SRSS-TB(LF)(SN); LCSC Part No C160404
L1: 60R@100MHz; L_1206_3216Metric; Manufacturer Part No MLB3216-600P4A(f); LCSC Part No C33600
MH1, MH2, MH3, MH4: Mount-M2; Generic-Mounthole
R1, R2: 5.1k; R_0603
U1: TPD4E05U06DQAR; USON-10_2.5x1.0mm_P0.5mm; Manufacturer Part No TPD4E05U06DQAR; LCSC Part No C138714

Connections:
DA+: J1.A6 (D+), J1.B6 (D+), J2.3, U1.1 (IO1), U1.4 (D2+), U1.7 (NC), U1.10 (NC)
DA-: J1.A7 (D-), J1.B7 (D-), J2.2, U1.2 (IO2), U1.5 (D2-), U1.6 (NC), U1.9 (NC)
GND: J2.4, L1.1
GNDPWR: D1.1 (A1), J1.A1 (GND), J1.B1 (GND), J1.S (SHIELD), L1.2, MH2.1, R1.2, R2.2, U1.3 (GND), U1.8 (GND)
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
VBUS: F1.1, J1.A4 (VBUS), J1.B4 (VBUS)
VCC: D1.2 (A2), F1.2, J2.1

Notes on the sheet:
Connector and shield
ESD
Mounting
Misc

Board: 2 copper layers, 18.0 x 16.5 mm, 14 parts (2 on the bottom side), 8 nets.

## KiCad design Rynok40_KicadFiles/Rynok40.kicad_pcb

Parts:
C1, C2, C5: 0.1uF; C_0805_2012Metric
C3, C4: 22pF; C_0805_2012Metric
C6: 1uF; C_0805_2012Metric
C7: 10uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43: SOD-123; D_SOD-123
J1: SM04B-SRSS-TB(LF)(SN); JST-SR-4; Manufacturer Part No SM04B-SRSS-TB(LF)(SN); LCSC Part No C160404
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34, MX35, MX36, MX38, MX42: MX-NoLED; MXOnly-1U-NoLED
MX12, MX25: MX-NoLED; MXOnly-1.75U-NoLED
MX13, MX37, MX43, MX44: MX-NoLED; MXOnly-1.25U-NoLED
MX24: MX-NoLED; MXOnly-1.5U-NoLED
MX39: MX-NoLED; MXOnly-2.75U-ReversedStabilizers-NoLED
MX40: MX-NoLED; MXOnly-6.25U-ReversedStabilizers-NoLED
MX41: MX-NoLED; MXOnly-2.25U-ReversedStabilizers-NoLED
R1, R2: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-MU; QFN-44-1EP_7x7mm_P0.5mm_EP5.2x5.2mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C5.1, C7.1, J1.1, R3.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), MX13.1 (COL), MX25.1 (COL), MX37.1 (COL), U1.26 (PD6)
COL1: MX2.1 (COL), MX14.1 (COL), MX26.1 (COL), MX38.1 (COL), U1.41 (PF0)
COL2: MX3.1 (COL), MX15.1 (COL), MX27.1 (COL), U1.40 (PF1)
COL3: MX4.1 (COL), MX16.1 (COL), MX28.1 (COL), MX39.1 (COL), U1.39 (PF4)
COL4: MX5.1 (COL), MX17.1 (COL), MX29.1 (COL), U1.38 (PF5)
COL5: MX6.1 (COL), MX18.1 (COL), MX30.1 (COL), MX40.1 (COL), MX44.1 (COL), U1.37 (PF6)
COL6: MX7.1 (COL), MX19.1 (COL), MX31.1 (COL), U1.36 (PF7)
COL7: MX8.1 (COL), MX20.1 (COL), MX32.1 (COL), MX41.1 (COL), U1.32 (PC7)
COL8: MX9.1 (COL), MX21.1 (COL), MX33.1 (COL), U1.31 (PC6)
COL9: MX10.1 (COL), MX22.1 (COL), MX34.1 (COL), MX42.1 (COL), U1.30 (PB6)
COL10: MX11.1 (COL), MX23.1 (COL), MX35.1 (COL), MX43.1 (COL), U1.29 (PB5)
COL11: MX12.1 (COL), MX24.1 (COL), MX36.1 (COL), U1.28 (PB4)
DN: J1.2, R1.2
DP: J1.3, R2.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.4, R4.2, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), U1.45 (GND), Y1.2, Y1.4
unnamed: C3.1, U1.17 (XTAL1), Y1.1
unnamed: C4.1, U1.16 (XTAL2), Y1.3
unnamed: C6.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D29.2 (A), MX29.2 (ROW)
unnamed: D30.2 (A), MX30.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D35.2 (A), MX35.2 (ROW)
unnamed: D36.2 (A), MX36.2 (ROW)
unnamed: D37.2 (A), MX37.2 (ROW)
unnamed: D38.2 (A), MX38.2 (ROW)
unnamed: D39.2 (A), MX39.2 (ROW)
unnamed: D40.2 (A), MX40.2 (ROW), MX44.2 (ROW)
unnamed: D41.2 (A), MX41.2 (ROW)
unnamed: D42.2 (A), MX42.2 (ROW)
unnamed: D43.2 (A), MX43.2 (ROW)
unnamed: R1.1, U1.3 (D-)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.2, SW1.2, U1.13 (~RESET)
unnamed: R4.1, U1.33 (~HWB~/PE2)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.19 (PD1)
ROW1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.27 (PD7)
ROW2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.1 (PE6)
ROW3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), U1.18 (PD0)

Board: 2 copper layers, 242.9 x 76.2 mm, 102 parts (58 on the bottom side), 70 nets.
